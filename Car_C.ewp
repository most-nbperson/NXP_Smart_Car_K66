# IAR project Car_C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Project_Setting\Linker; src\Drive
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_LED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Tools\IAR\arm\config\linker\NXP\MK66xX1M_18.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: Car_C.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK66xX1M_18.icf
  group Driver
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Project_Setting/Startup
    src/Project_Setting/Libs/: MK66F18.h
    src/Project_Setting/Startup/: start.c startup_MK66F18.s
  group User
    src/User/: CAMERA.c CAMERA.h connect.c connect.h control.c control.h encoder.c encoder.h HC_SR04.c HC_SR04.h include.h IRQ_Handler.c KEY.c KEY.h LED.c LED.h main.c OLED.c OLED.h picture.h pid.c pid.h speed.c speed.h type.c type.h
